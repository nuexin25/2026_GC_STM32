# Keil uVision project nx_car.uvprojx, settings and files
target nx_car (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: nx_car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../nx_Drivers/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/nx_Drivers
    ../nx_Drivers/Src/: bsp_Emm_V5.c Emm_V5.c hwt101ct.c bsp_imu.c bsp_test.c oled.c bsp_debug.c bsp_oled_ui.c bsp_key.c bsp_motor.c bsp_wheel_test.c bsp_mecanum.c bsp_chassis.c bsp_chassis_test.c bsp_qr.c bsp_qr_test.c bsp_rpi.c bsp_rpi_test.c bsp_route.c bsp_route_test.c bsp_vel_test.c bsp_vel_route.c bsp_tune.c LobotServoController.c bsp_servo.c bsp_arm.c bsp_arm_action.c bsp_align.c bsp_tt.c bsp_arm_test.c bsp_arm_seq.c bsp_arm_para.c bsp_align_test.c bsp_mission.c bsp_task.c bsp_task_dbg.c
software components: CMSIS:CORE 5.2.0
